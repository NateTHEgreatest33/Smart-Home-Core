
/*********************************************************************
*
*   NAME:
*       background_task.cpp
*
*   DESCRIPTION:
*       background task
*
*   Copyright 2024 Nate Lenze
*
*********************************************************************/

/*--------------------------------------------------------------------
                              INCLUDES
--------------------------------------------------------------------*/
#include "background_task.hpp"
#include "console.hpp"
#include "mailbox.hpp"

/*--------------------------------------------------------------------
                          GLOBAL NAMESPACES
--------------------------------------------------------------------*/

/*--------------------------------------------------------------------
                          LITERAL CONSTANTS
--------------------------------------------------------------------*/

/*--------------------------------------------------------------------
                                TYPES
--------------------------------------------------------------------*/

/*--------------------------------------------------------------------
                           MEMORY CONSTANTS
--------------------------------------------------------------------*/
#define HUNDRED_SEC_AS_MS   (1000*100) /* 100 sec represented as ms */

/*--------------------------------------------------------------------
                              VARIABLES
--------------------------------------------------------------------*/

/*--------------------------------------------------------------------
                              EXTERNS
--------------------------------------------------------------------*/
extern core::console Console;

/*--------------------------------------------------------------------
                                MACROS
--------------------------------------------------------------------*/

/*--------------------------------------------------------------------
                              PROCEDURES
--------------------------------------------------------------------*/

/*********************************************************************
*
*   PROCEDURE NAME:
*       background_task
*
*   DESCRIPTION:
*       background process
*
*********************************************************************/
void background_task
    (
    void
    )
{
/*----------------------------------------------------------
Local Variables
----------------------------------------------------------*/
static absolute_time_t s_current_100ms_timeout   = delayed_by_ms( get_absolute_time(), 100 );
static absolute_time_t s_current_100sec_timeout = delayed_by_ms( get_absolute_time(), HUNDRED_SEC_AS_MS );


/*----------------------------------------------------------
Main Loop
----------------------------------------------------------*/
while( true )
    {
    /*------------------------------------------------------
    Run console periodic
    ------------------------------------------------------*/
    Console.console_runtime();

    /*------------------------------------------------------
    Example 100ms timer
    ------------------------------------------------------*/
    if( s_current_100ms_timeout < get_absolute_time() )
        {
        s_current_100ms_timeout = delayed_by_ms( get_absolute_time(), 100 );
        }

    /*------------------------------------------------------
    example 100s timer
    ------------------------------------------------------*/
    if( s_current_100sec_timeout < get_absolute_time() )
        {
        s_current_100sec_timeout = delayed_by_ms( get_absolute_time(), HUNDRED_SEC_AS_MS );
        }
        
        
    }
}