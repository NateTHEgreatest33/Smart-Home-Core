# Keil uVision project module.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: module
  AfterMake: C:\KEIL_v5\ARM\ARMCC\bin\fromelf.exe --bincombined --output=module.bin module.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: C:\ti\TivaWare_C_Series-2.1.4.178;C:\ti\TivaWare_C_Series-2.1.4.178\inc;C:\ti\TivaWare_C_Series-2.1.4.178\driverlib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup.s main.c Timer1A.c Timer1A.h
    ./messageAPI/: messageAPI.c
    ./messageAPI/LoRa/: LoraAPI.c
  group Libraries
    C:/ti/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
software components: CMSIS:CORE 5.0.1
